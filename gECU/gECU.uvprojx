# Keil uVision project gECU.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1758 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gECU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Src;..\Drivers\include;..\CMSIS\Include;..\HardwareDefs_lpc17xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Core
    ./Src/: Main.c User.c WorkStates.c EcuConfig.c FaultTools.c gVCU_ECU.c Interrupts.c
    ../MolniaLib/: Config.c PowerManager.c
  group Drivers
    ../Drivers/source/: lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_iap.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_rtc.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c
  group HardwareFunc
    ../HardwareDefs_lpc17xx/: AdcFunc.c CanFunc.c I2cFunc.c MemoryFunc.c PwmFunc.c SpiFunc.c TimerFunc.c
  group Protocol
    ./Src/: Protocol.c ExternalProtocol.c PCanProtocol.c
    ../MolniaLib/: N_OBD.c
  group BoardDef
    ../BoardDefinitions/: MarineEcu_Board.c
  group Libs
    ./Src/: max11612.c
    ../Libs/: Btn8982.c TLE_6368g2.c filter.c
    ../MolniaLib/: MF_Tools.c DateTime.c FaultsServices.c
software components: Device:Startup 1.0.0
